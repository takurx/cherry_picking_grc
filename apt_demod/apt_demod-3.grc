<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>satnogs_apt_demod</value></param>
<param><key>author</key><value>Manolis Surligas (surligas@gmail.com)</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A generic APT demodulation block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>APT Generic Demodulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decimation</value></param>
<param><key>comment</key><value>Audio decimation after 
the quadrature demodulation</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>17000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>first_stage_decimation</value></param>
<param><key>comment</key><value>The first stage decimation tries to decrease 
the sampling rate of the device in order to keep
the CPU utilization of the next processing blocks
in acceptable levels especially for embedded devices.</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_bandwidth</value></param>
<param><key>comment</key><value>Audio decimation after 
the quadrature demodulation</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>satnogs.hw_rx_settings[rx_sdr_device]['samp_rate']</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>12.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate_rx, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(2*math.pi*deviation)/96000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_antenna</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>6</value></param>
<param><key>high_cutoff_freq</key><value>4.2e3</value></param>
<param><key>low_cutoff_freq</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate_rx/ ( first_stage_decimation  * int(samp_rate_rx/ first_stage_decimation / initial_bandwidth)) / audio_decimation</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_bb_gain</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>125</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/mocha/Desktop/1912_December/iq_NOAA_18_20191016T101359_137812000Hz_IQ.wav</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.008</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.008</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_1</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/sebastian/projects/satnogs/testbed/satnogs_164929_2018-06-20T14-47-18.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decoded_data_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/mocha/.satnogs/data/data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev_args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=00000002</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_correction_per_sec</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable_iq_dump</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/mocha/Desktop/test4windows.ogg</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>[0.5, 0.5]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>lo_offset</value></param>
<param><key>decim</key><value>int(samp_rate_rx/filter_rate)</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_if_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/iq.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>satnogs.handle_rx_antenna(rx_sdr_device, antenna)</value></param>
<param><key>bb_gain0</key><value>satnogs.handle_rx_bb_gain(rx_sdr_device, bb_gain)</value></param>
<param><key>bw0</key><value>samp_rate_rx</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>satnogs.handle_rx_if_gain(rx_sdr_device, if_gain)</value></param>
<param><key>gain0</key><value>satnogs.handle_rx_rf_gain(rx_sdr_device, rf_gain)</value></param>
<param><key>args</key><value>satnogs.handle_rx_dev_args(rx_sdr_device, dev_args)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_rx</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>8000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>int((samp_rate_rx/ ( first_stage_decimation  * int(samp_rate_rx/ first_stage_decimation / initial_bandwidth)) / audio_decimation)/2)</value></param>
<param><key>interp</key><value>4*4160</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>decim</key><value>48000</value></param>
<param><key>interp</key><value>int(samp_rate_rx/ ( first_stage_decimation  * int(samp_rate_rx/ first_stage_decimation / initial_bandwidth)) / audio_decimation)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_rf_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rigctl_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4532</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>rx_freq - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>satnogs.handle_rx_dev_args(rx_sdr_device, dev_args)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>137812000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtlsdr</value></param>
</block>
<block>
<key>satnogs_coarse_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_coarse_doppler_correction_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sampling_rate</key><value>samp_rate_rx</value></param>
<param><key>target_freq</key><value>rx_freq</value></param>
</block>
<block>
<key>satnogs_iq_sink</key>
<param><key>id</key><value>satnogs_iq_sink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>iq_file_path</value></param>
<param><key>scale</key><value>32767</value></param>
<param><key>status</key><value>enable_iq_dump</value></param>
</block>
<block>
<key>satnogs_noaa_apt_sink</key>
<param><key>id</key><value>satnogs_noaa_apt_sink_0_0</value></param>
<param><key>flip</key><value>True</value></param>
<param><key>filename_png</key><value>/home/mocha/Desktop/test_ogg.png</value></param>
<param><key>height</key><value>1800</value></param>
<param><key>width</key><value>2080</value></param>
<param><key>sync</key><value>True</value></param>
</block>
<block>
<key>satnogs_ogg_encoder</key>
<param><key>id</key><value>satnogs_ogg_encoder_0</value></param>
<param><key>filename</key><value>file_path</value></param>
<param><key>quality</key><value>1.0</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
</block>
<block>
<key>satnogs_ogg_source</key>
<param><key>id</key><value>satnogs_ogg_source_0</value></param>
<param><key>channels</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/mocha/Desktop/test4windows.ogg</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>satnogs_tcp_rigctl_msg_source</key>
<param><key>id</key><value>satnogs_tcp_rigctl_msg_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>addr</key><value>"127.0.0.1"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>mode</key><value>True</value></param>
<param><key>port</key><value>rigctl_port</value></param>
<param><key>interval</key><value>1000/doppler_correction_per_sec</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>waterfall_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>10</value></param>
<param><key>samp_rate</key><value>audio_samp_rate*2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_file_path</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/mocha/Desktop/waterfall.dat</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>satnogs_iq_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_uchar_to_float_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_1</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>satnogs_ogg_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>satnogs_noaa_apt_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ogg_source_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
</flow_graph>
