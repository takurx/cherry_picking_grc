<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>decode_noaa_apt_from_wav_48k</value></param>
<param><key>description</key><value>Ref. https://community.libre.space/t/noaa-apt-slanting-issues/2264</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decimation</value></param>
<param><key>comment</key><value>Audio decimation after 
the quadrature demodulation</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>first_stage_decimation</value></param>
<param><key>comment</key><value>The first stage decimation tries to decrease 
the sampling rate of the device in order to keep
the CPU utilization of the next processing blocks
in acceptable levels especially for embedded devices.</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_bandwidth</value></param>
<param><key>comment</key><value>Audio decimation after 
the quadrature demodulation</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>6</value></param>
<param><key>high_cutoff_freq</key><value>4.2e3</value></param>
<param><key>low_cutoff_freq</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate_rx/ ( first_stage_decimation  * int(samp_rate_rx/ first_stage_decimation / initial_bandwidth)) / audio_decimation</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/sebastian/projects/satnogs/testbed/satnogs_164929_2018-06-20T14-47-18.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>[0.5, 0.5]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>8000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int((samp_rate_rx/ ( first_stage_decimation  * int(samp_rate_rx/ first_stage_decimation / initial_bandwidth)) / audio_decimation)/2)</value></param>
<param><key>interp</key><value>4*4160</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>48000</value></param>
<param><key>interp</key><value>int(samp_rate_rx/ ( first_stage_decimation  * int(samp_rate_rx/ first_stage_decimation / initial_bandwidth)) / audio_decimation)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>satnogs_noaa_apt_sink</key>
<param><key>id</key><value>satnogs_noaa_apt_sink_0_0</value></param>
<param><key>flip</key><value>False</value></param>
<param><key>filename_png</key><value>/home/mocha/Desktop/satnogs_1389117_2019-12-17T09-31-56_ogg.png</value></param>
<param><key>height</key><value>1800</value></param>
<param><key>width</key><value>2080</value></param>
<param><key>sync</key><value>True</value></param>
</block>
<block>
<key>satnogs_ogg_source</key>
<param><key>id</key><value>satnogs_ogg_source_0</value></param>
<param><key>channels</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/home/mocha/Desktop/satnogs_1389117_2019-12-17T09-31-56.ogg</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>satnogs_noaa_apt_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ogg_source_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
